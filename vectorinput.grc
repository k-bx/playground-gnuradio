options:
  parameters:
    author: kb
    generate_options: qt_gui
    id: my_second_python
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: vectorLength
  id: variable
  parameters:
    value: '16'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vectorLength
    type: float
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vectorLength
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vectorLength
    type: float
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: vectorLength
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, vectorSize=16):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Max Hold Block',   # will show up in GRC\n            in_sig=[(np.float32, vectorSize), (np.float32, vectorSize)],\n            out_sig=[(np.float32, vectorSize), (np.float32, vectorSize)],\n        )\n        \n\n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        for portIndex in range(len(input_items)):\n            for vectorIndex in range(len(input_items[portIndex])):\n                maxValue = np.max(input_items[portIndex][vectorIndex])\n                for sampleIndex in range(len(input_items[portIndex][vectorIndex])):\n                    output_items[portIndex][vectorIndex][sampleIndex] = maxValue\n        return len(output_items[0])\n\n"
    vectorSize: '16'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: sinusoid
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: noise
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: sinusoid
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: noise
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_stream_to_vector_1, '0']
- [analog_noise_source_x_0, '0', virtual_sink_1, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_0, '0', virtual_sink_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_0, '0']
- [blocks_stream_to_vector_1, '0', epy_block_0, '1']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_stream_1, '0', qtgui_time_sink_x_1, '0']
- [epy_block_0, '0', blocks_vector_to_stream_0, '0']
- [epy_block_0, '1', blocks_vector_to_stream_1, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0, '1']
- [virtual_source_1, '0', qtgui_time_sink_x_1, '1']

metadata:
  file_format: 1
  grc_version: v3.10.2.0-68-g62a7e451
